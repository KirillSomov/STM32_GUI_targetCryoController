# Keil uVision project GUI_targetCryoController.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUI_targetCryoController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\App_Layer;.\lib\Func_Layer;.\lib\HW_Layer;.\lib\SPL;.\lib\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App_Layer
    ./lib/App_Layer/: GUI_cryoTargetController.c GUI_cryoTargetController.h main.c
  group Func_Layer
    ./lib/Func_Layer/: Font.h GUI.c GUI.h link.h
  group HW_Layer
    ./lib/HW_Layer/: CPU.c CPU.h LCD_ILI9341.c LCD_ILI9341.h SPI.c SPI.h Timer.c Timer.h GPIO.c GPIO.h
  group SPL
    ./lib/SPL/: misc.c misc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h
  group CMSIS
    ./lib/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx_conf.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
